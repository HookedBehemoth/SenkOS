LICENSE = "Zlib"
LIC_FILES_CHKSUM = "file://lynx/system.h;beginline=1;endline=21;md5=6e0cf2df8b8e4965b6e5473c72cd041d"
LIBRETRO_REPO = "libretro-handy"
LIBRETRO_REV = "bc55d462f0b2d6b073ea93dc552ebd73cec60fd1"
SRC_URI[sha256sum] = "65ad333df22aab7f3c8156c21ffd0b8da1ef09c7a7f1775df964b89986aa7324"
require libretro-core.inc
SUMMARY = "Atari Lynx (Handy) libretro core"
