LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=5dd99a4a14d516c44d0779c1e819f963"
LIBRETRO_REPO = "pcsx_rearmed"
LIBRETRO_REV = "ff81ed17a15241d2f3730cdd7585b38e172532ca"
SRC_URI[sha256sum] = "23e0006435e66503e1b862daaf8a47cb6bee120f4ca82482c08ec129668a35c5"
require libretro-core.inc
SUMMARY = "PlayStation (PCSX ReARMed, ARM64 dynarec) libretro core"
LIBRETRO_MAKEFILE = "Makefile.libretro"
