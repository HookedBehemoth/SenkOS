LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=6e233eda45c807aa29aeaa6d94bc48a2"
LIBRETRO_REPO = "beetle-ngp-libretro"
LIBRETRO_REV = "a50d5ac288a81f2104ddf43195a4efdd15c72227"
SRC_URI[sha256sum] = "ffeabf2a357548f3a55423d542c31bb1e08571d81d7104f8213df3bfa2eb9c9f"
require libretro-core.inc
SUMMARY = "Neo Geo Pocket / Color (Beetle NGP) libretro core"
LIBRETRO_CORE = "mednafen_ngp"
