LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=6e233eda45c807aa29aeaa6d94bc48a2"
LIBRETRO_REPO = "beetle-wswan-libretro"
LIBRETRO_REV = "4b01295838ea89e3f1355bbe4cb5cf98aa6108cd"
SRC_URI[sha256sum] = "bce15c0e2505e15b7b55fa1d51b4a12219d07a67be62bbca5c26678d0d89c659"
require libretro-core.inc
SUMMARY = "WonderSwan / Color (Beetle WonderSwan) libretro core"
LIBRETRO_CORE = "mednafen_wswan"
