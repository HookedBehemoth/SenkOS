FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://senkos.cfg file://0001-init-no-fixed-sleeps-on-shutdown.patch"
