# mesa_clc/panfrost_compile have to match the target Mesa
require mesa-main.inc
