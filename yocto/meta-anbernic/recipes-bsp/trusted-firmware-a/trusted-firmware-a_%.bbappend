COMPATIBLE_MACHINE:rg35xx-sp = "rg35xx-sp"
