LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://stella/license.txt;md5=435d4178fd08b25f9cf911f1c3a0ce1d"
LIBRETRO_REPO = "stella2014-libretro"
LIBRETRO_REV = "7d1361e407e63f29e52892655069e5fb4096e691"
SRC_URI[sha256sum] = "c0f5e53f3c21e7760e434784634d44a02e57a30917da5279cfd3add4736afd82"
require libretro-core.inc
SUMMARY = "Atari 2600 (Stella 2014) libretro core"
