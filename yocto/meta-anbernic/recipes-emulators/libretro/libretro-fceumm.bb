LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://Copying;md5=6e233eda45c807aa29aeaa6d94bc48a2"
LIBRETRO_REPO = "libretro-fceumm"
LIBRETRO_REV = "7a542dab1e87679921962a9f056186eca425c0c2"
SRC_URI[sha256sum] = "f80b5c1df39e22d78791b1867ea79f3ec8c0823e4b1f82b3f89e432c614a6c53"
require libretro-core.inc
SUMMARY = "NES / Famicom (FCEUmm) libretro core"
LIBRETRO_MAKEFILE = "Makefile.libretro"
