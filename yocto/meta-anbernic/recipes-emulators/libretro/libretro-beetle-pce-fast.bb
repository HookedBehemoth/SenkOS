LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=6e233eda45c807aa29aeaa6d94bc48a2"
LIBRETRO_REPO = "beetle-pce-fast-libretro"
LIBRETRO_REV = "1c693c630121366f0b819d785762f1ce5b3a68d0"
SRC_URI[sha256sum] = "8b427af5f0dcb07067f69699eab5f37386fed757cf373216c62ea20e75fb1e02"
require libretro-core.inc
SUMMARY = "PC Engine / TurboGrafx(-CD) (Beetle PCE Fast) libretro core"
LIBRETRO_CORE = "mednafen_pce_fast"
