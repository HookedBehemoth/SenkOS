LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://COPYING;md5=751419260aa954499f7abaabaa882bbe"
LIBRETRO_REPO = "gambatte-libretro"
LIBRETRO_REV = "d9d6cd06382d1ced30de34d56d3609452323dab1"
SRC_URI[sha256sum] = "bd39cd38662135d17e221a7fd34baf2908a40065ade16edf2e8d1168b21b921e"
require libretro-core.inc
SUMMARY = "Game Boy / Color (Gambatte) libretro core"
LIBRETRO_MAKEFILE = "Makefile.libretro"
