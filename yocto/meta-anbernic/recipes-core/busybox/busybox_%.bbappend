FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://anbernic.cfg file://0001-init-no-fixed-sleeps-on-shutdown.patch"
